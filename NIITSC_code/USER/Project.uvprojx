# Keil uVision project Project.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\FWLIB\inc;..\USER;..\HARDWARE\MPU;..\HARDWARE\OPENMV;..\HARDWARE\OPS;..\HARDWARE\QRCODE;..\HARDWARE\SCREEN;..\HARDWARE\ZIGBEE;..\SYSTEM\Include;..\HARDWARE\INFRARED;..\HARDWARE\OLED;..\HARDWARE\ENCODER;..\HARDWARE\MOTOR;..\HARDWARE\CONTROL;..\HARDWARE\PID;..\HARDWARE\KEYMATRIX;..\HARDWARE\PWM;..\HARDWARE\SERIAL;..\HARDWARE\KEYNDISP;..\UTILS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_cec.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c flags.c
  group SYSTEM
    ../SYSTEM/Source/: delay.c led.c sys.c
  group HARDWARE
    ../HARDWARE/MPU/: mpu.c
    ../HARDWARE/OPENMV/: openmv.c
    ../HARDWARE/OPS/: ops.c
    ../HARDWARE/QRCODE/: qrcode.c
    ../HARDWARE/SCREEN/: screen.c
    ../HARDWARE/ZIGBEE/: zigbee.c
    ../HARDWARE/INFRARED/: infrared.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/ENCODER/: encoder.c
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/CONTROL/: control.c
    ../HARDWARE/SERIAL/: serial.c
    ../HARDWARE/KEYNDISP/: keyndisp.c
